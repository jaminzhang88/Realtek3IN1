# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None; default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CONFIG_PLATFORM_8711B
  ICCARM.CCDiagSuppress: Be006,Pa050,Pa039,Pa089,Pe014,Pe047,Pe068,Pe089,Pe167,Pe177,Pe186,Pe188,Pe375,Pe550,Pe550,Pe223,Pe549,Pe550
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v8.1.2\Source\include; ..\..\..\component\os\freertos\freertos_v8.1.2\Source\portable\IAR\ARM_CM4F; ..\..\..\component\os\os_dep\include; ..\..\..\component\common\api\network\include; ..\..\..\component\common\api; ..\..\..\component\common\api\at_cmd; ..\..\..\component\common\api\platform; ..\..\..\component\common\api\wifi; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\component\common\api\wifi\rtw_wowlan; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\wpa_supplicant; ..\..\..\component\common\application; ..\..\..\component\common\application\mqtt\MQTTClient; ..\..\..\component\common\application\mqtt\MQTTPacket; ..\..\..\component\common\example; ..\..\..\component\common\example\wlan_fast_connect; ..\..\..\component\common\drivers\modules; ..\..\..\component\common\drivers\sdio\realtek\sdio_host\inc; ..\..\..\component\common\drivers\inic\rtl8711b; ..\..\..\component\common\drivers\usb_class\device; ..\..\..\component\common\drivers\usb_class\device\class; ..\..\..\component\common\drivers\wlan\realtek\include; ..\..\..\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\component\common\drivers\wlan\realtek\src\hci; ..\..\..\component\common\drivers\wlan\realtek\src\hal; ..\..\..\component\common\drivers\wlan\realtek\src\hal\rtl8711b; ..\..\..\component\common\drivers\wlan\realtek\src\hal\OUTSRC; ..\..\..\component\common\drivers\wlan\realtek\wlan_ram_map\rom; ..\..\..\component\common\network; ..\..\..\component\common\network\lwip\lwip_v1.4.1\port\realtek\freertos; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include\lwip; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include\ipv4; ..\..\..\component\common\network\lwip\lwip_v1.4.1\port\realtek; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\common\test; ..\..\..\component\common\utilities; ..\..\..\component\soc\realtek\8711b\app\monitor\include; ..\..\..\component\soc\realtek\8711b\cmsis; ..\..\..\component\soc\realtek\8711b\cmsis\device; ..\..\..\component\soc\realtek\8711b\fwlib; ..\..\..\component\soc\realtek\8711b\fwlib\include; ..\..\..\component\soc\realtek\8711b\fwlib\ram_lib\crypto; ..\..\..\component\soc\realtek\8711b\fwlib\rom_lib; ..\..\..\component\soc\realtek\8711b\swlib\os_dep\include; ..\..\..\component\soc\realtek\8711b\swlib\std_lib\include; ..\..\..\component\soc\realtek\8711b\swlib\std_lib\libc\include; ..\..\..\component\soc\realtek\8711b\swlib\std_lib\libc\rom\string; ..\..\..\component\soc\realtek\8711b\swlib\std_lib\libgcc\rtl8195a\include; ..\..\..\component\soc\realtek\8711b\swlib\rtl_lib; ..\..\..\component\soc\realtek\8711b\misc; ..\..\..\component\soc\realtek\8711b\misc\os; ..\..\..\component\common\mbed\api; ..\..\..\component\common\mbed\hal; ..\..\..\component\common\mbed\hal_ext; ..\..\..\component\common\mbed\targets\cmsis\rtl8711b; ..\..\..\component\common\mbed\targets\hal\rtl8711b; ..\..\..\component\common\network\coap\include; ..\..\..\component\common\application\andlink\libcoap-4.1.1; ..\..\..\component\common\application\ayla\libayla\include; ..\..\..\component\common\application\ayla\libayla\libada; ..\..\..\component\common\application\ayla\libayla\libada\include; ..\..\..\component\common\application\ayla\libayla\libayla\include; ..\..\..\component\common\application\ayla\libayla\ext\jsmn; ..\..\..\component\common\application\ayla\libayla\libnet\include; ..\..\..\component\common\application\ayla\libayla\libnet\ameba\include; ..\..\..\component\common\application\ayla\libayla\libadw\include; ..\..\..\component\common\application\ayla\ayla_demo\src; ..\..\..\component\common\application\ayla\libayla\libayla\include\ayla; ..\..\..\component\common\network\ssl\mbedtls-2.4.0\include; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include\posix; ..\..\..\component\common\network\ssl\mbedtls-2.4.0\include\mbedtls; ..\..\..\component\common\network\websocket; ..\..\..\component\common\application\airkiss; ..\..\..\component\common\application\ayla\ayla_demo\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc; ..\..\..\component\soc\realtek\8711b\cmsis; ..\..\..\component\soc\realtek\8711b\swlib\os_dep\include; ..\..\..\component\os\freertos\freertos_v8.1.2\Source\include; ..\..\..\component\os\freertos\freertos_v8.1.2\Source\portable\IAR\ARM_CM4F
  OBJCOPY.OOCOutputFile: Project.bin
  prebuild: CSCRIPT  "..\..\..\component\soc\realtek\8711b\misc\iar_utility\common\prebuild.vbs" "$PROJ_DIR$" "1" "0x08100000"
  postbuild: CSCRIPT  "..\..\..\component\soc\realtek\8711b\misc\iar_utility\common\postbuild_img2.vbs" "$TARGET_DIR$" "$PROJ_DIR$"
  ILINK.IlinkOutputFile: application.axf
  ILINK.IlinkKeepSymbols: bootloader
  ILINK.IlinkIcfFile: image2.icf
  ILINK.IlinkExtraOptions: --pi_veneers
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group airkiss
    ../../../component/common/application/airkiss/: airkiss.c lib_airkisscloud.a lib_rt_airkiss_algo.a libairkiss.a libairkiss_log.a prefix_libwxcloud.a wifi_airkiss.c wifi_airkiss.h
  group Ayla/Ayla_demo
    ../../../component/common/application/ayla/ayla_demo/src/: Ayla_cloud.c Ayla_demo_common.c Ayla_demo_conf.c Ayla_demo_ledevb.c Ayla_demo_ota.c Ayla_demo_sched.c Ayla_demo_stub.c Ayla_demo_wifi.c config_allinfo.c
  group Ayla/libada
    ../../../component/common/application/ayla/libayla/libada/: ada_conf.c ada_err.c client.c client_auth.c client_conf.c client_ota.c client_prop.c conf_json.c dnss.c dnss_util.c lan.c log_page.c notify.c oem.c prop_mgr.c prop_page.c sched.c schedeval.c server_mem.c server_req.c sprop.c sys_conf.c
    ../../../component/common/application/ayla/libayla/libada/al/ameba/: ada_lock.c ameba_conf.c ameba_log.c client_task.c conf_table.c http_client.c notify_task.c sched_conf.c server.c stubs.c
    ../../../component/common/application/ayla/libayla/libada/certs/: ca_certs_der.c
    ../../../component/common/application/ayla/libayla/libada/text/: custom.css.c regtoken.html.c
  group Ayla/libadw
    ../../../component/common/application/ayla/libayla/libadw/: adw_wifi_conf.c wifi.c wifi_ameba.c wifi_page.c
    ../../../component/common/application/ayla/libayla/libadw/text/: lock.gif.c refresh.gif.c wifi.html.c wifi.js.c
  group Ayla/libayla
    ../../../component/common/application/ayla/libayla/libayla/arch/ameba/: clock.c conf_flash.c malloc.c
    ../../../component/common/application/ayla/libayla/libayla/: clock_fmt.c clock_sw.c clock_utils.c cmd_handle.c conf.c crc.c crc16.c crc8.c endian.c format_mac.c format_string.c hostname_valid.c http.c jsmn_get.c jsmn_iterate.c json_format_string.c log.c log_cmd.c log_conf.c log_io.c lookup_by_name.c lookup_by_val.c parse_argv.c parse_date.c parse_hex.c parse_mac.c parse_url.c timer.c uri_arg_allowed_map.c uri_decode.c uri_encode.c utf8.c xml.c xml_decode.c xml_encode.c
    ../../../component/common/application/ayla/libayla/ext/jsmn/: jsmn.c
  group Ayla/libnet
    ../../../component/common/application/ayla/libayla/libnet/ameba/: ipaddr_fmt.c net_mbuf.c net_realtek.c ssl.c
  group Ayla_ameba
    ../../../component/common/application/ayla/ayla_demo/src/: Ayla_demo_ledkey.c
    ../../../component/common/application/ayla/libayla/libadw/: wifi_ameba_drv.c
  group cmsis
    ../../../component/soc/realtek/8711b/cmsis/device/: app_start.c
    ../../../component/soc/realtek/8711b/fwlib/ram_lib/: startup.c
  group console
    ../../../component/common/api/at_cmd/: atcmd_cloud.c atcmd_lwip.c atcmd_sys.c atcmd_wifi.c log_service.c
    ../../../component/soc/realtek/8711b/app/monitor/ram/: low_level_io.c monitor.c rtl_consol.c rtl_trace.c
  group lib
    ../../../component/soc/realtek/8711b/misc/bsp/lib/common/IAR/: lib_andlink.a lib_http.a lib_mdns.a lib_p2p.a lib_platform.a lib_rtlstd.a lib_websocket.a lib_wlan.a lib_wlan_mp.a lib_wps.a lib_xmodem.a
  group network/api
    ../../../component/common/api/: lwip_netconf.c
  group network/api/wifi
    ../../../component/common/api/wifi/: wifi_conf.c wifi_ind.c wifi_promisc.c wifi_simple_config.c wifi_util.c
  group network/api/wifi/rtw_wpa_supplicant
    ../../../component/common/api/wifi/rtw_wpa_supplicant/wpa_supplicant/: wifi_eap_config.c wifi_p2p_config.c wifi_wps_config.c
  group network/app
    ../../../component/common/api/network/src/: ping_test.c wlan_network.c
    ../../../component/common/utilities/: ssl_client.c tcptest.c
  group network/app/mqtt
    ../../../component/common/application/mqtt/MQTTClient/: MQTTClient.c MQTTFreertos.c
    ../../../component/common/application/mqtt/MQTTPacket/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group network/coap
    ../../../component/common/network/coap/: sn_coap_ameba_port.c sn_coap_builder.c sn_coap_header_check.c sn_coap_parser.c sn_coap_protocol.c
  group network/googlenest
    ../../../component/common/application/google/: google_tls.c
  group network/http
    ../../../component/common/network/httpc/: httpc_tls.c
    ../../../component/common/network/httpd/: httpd_tls.c
  group network/lwip
    ../../../component/common/network/dhcp/: dhcps.c
  group network/lwip/api
    ../../../component/common/network/lwip/lwip_v1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group network/lwip/core
    ../../../component/common/network/lwip/lwip_v1.4.1/src/core/: def.c dhcp.c dns.c init.c lwip_timers.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group network/lwip/core/ipv4
    ../../../component/common/network/lwip/lwip_v1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group network/lwip/netif
    ../../../component/common/network/lwip/lwip_v1.4.1/src/netif/: etharp.c
  group network/lwip/port
    ../../../component/common/network/lwip/lwip_v1.4.1/port/realtek/freertos/: ethernetif.c sys_arch.c
    ../../../component/common/drivers/wlan/realtek/src/osdep/: lwip_intf.c
  group network/mdns
    ../../../component/common/network/mDNS/: mDNSPlatform.c
  group network/polarssl/polarssl
    ../../../component/common/network/ssl/polarssl-1.3.8/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecp.c ecp_curves.c ecp_ram.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net.c oid.c padlock.c pbkdf2.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_srv.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group network/websocket
    ../../../component/common/network/websocket/: wsclient_tls.c
  group os/freertos
    ../../../component/os/freertos/: cmsis_os.c freertos_service.c
    ../../../component/os/freertos/freertos_v8.1.2/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group os/freertos/portable
    ../../../component/os/freertos/freertos_v8.1.2/Source/portable/MemMang/: heap_5.c
    ../../../component/os/freertos/freertos_v8.1.2/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group os/osdep
    ../../../component/os/os_dep/: device_lock.c osdep_service.c
  group peripheral/api
    ../../../component/common/mbed/targets/hal/rtl8711b/: analogin_api.c dma_api.c efuse_api.c flash_api.c gpio_api.c gpio_irq_api.c i2c_api.c i2s_api.c nfc_api.c pinmap.c pinmap_common.c port_api.c pwmout_api.c rtc_api.c serial_api.c sleep.c spi_api.c sys_api.c timer_api.c us_ticker.c us_ticker_api.c wait_api.c wdt_api.c
  group peripheral/rtl8710b
    ../../../component/soc/realtek/8711b/fwlib/ram_lib/: rtl8710b_dsleepcfg.c rtl8710b_dstandbycfg.c rtl8710b_intfcfg.c rtl8710b_pinmapcfg.c rtl8710b_sleepcfg.c
    ../../../component/soc/realtek/8711b/misc/: rtl8710b_ota.c
  group peripheral/wlan
    ../../../component/common/drivers/wlan/realtek/src/core/option/: rtw_opt_power_by_rate.c rtw_opt_power_limit.c rtw_opt_skbuf.c
  group TLS
    ../../../component/common/network/ssl/mbedtls-2.4.0/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group TLS/ssl_ram_map
    ../../../component/common/network/ssl/ssl_ram_map/rom/: rom_ssl_ram_map.c
    ../../../component/common/network/ssl/ssl_ram_map/: ssl_ram_map.c
  group user
    ../src/: main.c
  group utilities
    ../../../component/common/utilities/: cJSON.c http_client.c uart_socket.c webserver.c xml.c
    ../../../component/common/application/xmodem/: uart_fw_update.c
  group utilities/example
    ../../../component/common/example/bcast/: example_bcast.c
    ../../../component/common/example/coap/: example_coap.c
    ../../../component/common/example/eap/: example_eap.c
    ../../../component/common/example/: example_entry.c
    ../../../component/common/example/get_beacon_frame/: example_get_beacon_frame.c
    ../../../component/common/example/googlenest/: example_google.c
    ../../../component/common/example/high_load_memory_use/: example_high_load_memory_use.c
    ../../../component/common/example/http_client/: example_http_client.c
    ../../../component/common/example/http_download/: example_http_download.c
    ../../../component/common/example/httpc/: example_httpc.c
    ../../../component/common/example/httpd/: example_httpd.c
    ../../../component/common/example/inic_gspi/: example_inic_gspi.c
    ../../../component/common/example/mcast/: example_mcast.c
    ../../../component/common/example/mdns/: example_mdns.c
    ../../../component/common/example/mqtt/: example_mqtt.c
    ../../../component/common/example/nonblock_connect/: example_nonblock_connect.c
    ../../../component/common/example/ota_http/: example_ota_http.c
    ../../../component/common/example/rarp/: example_rarp.c
    ../../../component/common/example/sntp_showtime/: example_sntp_showtime.c
    ../../../component/common/example/socket_select/: example_socket_select.c
    ../../../component/common/example/ssl_download/: example_ssl_download.c
    ../../../component/common/example/ssl_server/: example_ssl_server.c
    ../../../component/common/example/tcp_keepalive/: example_tcp_keepalive.c
    ../../../component/common/example/uart_atcmd/: example_uart_atcmd.c
    ../../../component/common/example/uart_firmware_update/: example_uart_update.c
    ../../../component/common/example/wifi_mac_monitor/: example_wifi_mac_monitor.c
    ../../../component/common/example/wifi_roaming/: example_wifi_roaming.c
    ../../../component/common/example/wlan_fast_connect/: example_wlan_fast_connect.c
    ../../../component/common/example/wlan_scenario/: example_wlan_scenario.c
    ../../../component/common/example/websocket/: example_wsclient.c
    ../../../component/common/example/xml/: example_xml.c
  group utilities/wigadget
    ../../../component/common/application/wigadget/: cloud_link.c shtc1.c wigadget.c
